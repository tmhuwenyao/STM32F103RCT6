# Keil uVision project STM32F103RCT6.uvprojx, settings and files
target STM32F103RCT6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_STUDY +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User\drives\inc;..\User\app\inc;..\User;..\User\font
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/drives/src/: bsp.c bsp_can.c bsp_key.c bsp_led.c bsp_spi.c bsp_systick.c bsp_timer.c ST_string.c bsp_iic.c bsp_usart.c bsp_adc.c
  group APP
    ../User/app/src/: dht11.c oleddisplay.c rc522.c smokedetect.c externalcomm.c eeprom.c flash.c esp8266.c nrf24l01.c stepmotor.c
  group FONT
    ../User/font/: oledfont.c
  group DOC
    ../Doc/: readme.txt
